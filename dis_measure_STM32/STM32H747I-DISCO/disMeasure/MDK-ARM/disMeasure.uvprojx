# Keil uVision project disMeasure.uvprojx, settings and files
target disMeasure_CM4 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x10000000-0x10047FFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: disMeasure_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_DIRECT_SMPS_SUPPLY,HAVE_NETWORK_INFO
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: stm32h747xx_flash_CM4.sct
  group Application/MDK-ARM
    ../: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Lib
    ../Middlewares/ST/AI/Lib/NetworkRuntime1201_CM7_Keil.lib/: NetworkRuntime1201_CM7_Keil.lib
  group Application/User/Middlewares/ST/AI/Misc
    ../Middlewares/ST/AI/Misc/Src/: syscalls.c lc_print.c ai_device_adaptor.c aiTestUtility.c aiTestHelper_ST_AI.c
  group Drivers/BSP/STM32H747I-DISCO
    ../Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery_qspi.c stm32h747i_discovery_sdram.c
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c stm32h747i_discovery_bus.c stm32h747i_discovery_lcd.c
  group Drivers/BSP/Components/mt25tl01g
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/BSP/Components/is42s32800j
    ../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Application/User/CM7/AI/App
    ../CM7/AI/App/: network_data.c network.c user_init.c app_x-cube-ai.c network_weights.c
  group Drivers/BSP/Components/otm8099a
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/Components/nt35510
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Drivers/BSP/Components/nt35510/: nt35510.c nt35510_reg.c
  group Drivers/BSP/Components/adv7533
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Drivers/BSP/Components/adv7533/: adv7533.c adv7533_reg.c
  group Utilities
    ../../../Desktop/STM32H7Firmware/STM32CubeH7/Utilities/lcd/: stm32_lcd.c
target disMeasure_CM7 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: disMeasure_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_DIRECT_SMPS_SUPPLY,HAVE_NETWORK_INFO
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Middlewares\ST\AI\Inc;..\Middlewares\ST\AI\Misc\Inc;..\Drivers\BSP\Components\mt25tl01g;..\Drivers\BSP\STM32H747I-DISCO;..\Drivers\BSP\Components\is42s32800j;..\CM7\AI\App;..\Drivers\BSP\Components\Common;..\Utilities\lcd;..\Utilities\Fonts;..\Drivers\BSP\Components\Common;..\Utilities\lcd;..\Utilities\Fonts
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
software components: CMSIS:CORE 6.1.0
